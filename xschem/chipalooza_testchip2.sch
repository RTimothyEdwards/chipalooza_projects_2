v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {1.8V supply} -680 -870 0 0 0.5 0.5 {}
T {1.8V supply} -680 -220 0 0 0.5 0.5 {}
T {1.8V supply} 440 -710 0 0 0.5 0.5 {}
T {Chipalooza test chip #2} -4820 -2050 0 0 0.6 0.6 {}
N 270 -1150 330 -1150 {
lab=vccd1}
N 330 -1150 330 -180 {
lab=vccd1}
N 270 -180 330 -180 {
lab=vccd1}
N 270 -360 330 -360 {
lab=vccd1}
N 270 -520 330 -520 {
lab=vccd1}
N 270 -830 330 -830 {
lab=vccd1}
N 270 -670 330 -670 {
lab=vccd1}
N 270 -1000 330 -1000 {
lab=vccd1}
N 330 -1300 330 -1150 {
lab=vccd1}
N 330 -1330 380 -1330 {
lab=vccd1}
N 270 -1170 360 -1170 {
lab=vssd1}
N 380 -1170 380 -200 {
lab=vssd1}
N 270 -200 360 -200 {
lab=vssd1}
N 270 -380 360 -380 {
lab=vssd1}
N 270 -540 360 -540 {
lab=vssd1}
N 270 -850 360 -850 {
lab=vssd1}
N 270 -690 360 -690 {
lab=vssd1}
N 270 -1020 360 -1020 {
lab=vssd1}
N 380 -1260 380 -1170 {
lab=vssd1}
N 380 -1260 420 -1260 {
lab=vssd1}
N -500 -1330 -450 -1330 {
lab=vdda2}
N -500 -1280 -470 -1280 {
lab=vccd2}
N -470 -360 -400 -360 {
lab=vccd2}
N -470 -1260 -470 -360 {
lab=vccd2}
N -470 -520 -390 -520 {
lab=vccd2}
N -470 -670 -380 -670 {
lab=vccd2}
N -470 -1000 -400 -1000 {
lab=vccd2}
N -490 -1210 -490 -390 {
lab=vssd2}
N -490 -390 -490 -380 {
lab=vssd2}
N -490 -380 -400 -380 {
lab=vssd2}
N -490 -1020 -400 -1020 {
lab=vssd2}
N -490 -690 -380 -690 {
lab=vssd2}
N -490 -540 -390 -540 {
lab=vssd2}
N -580 -980 -400 -980 {
lab=io_analog[10]}
N -580 -1120 -400 -1120 {
lab=vdd_spare_3}
N -570 -810 -400 -810 {
lab=io_analog[9]}
N -570 -650 -380 -650 {
lab=io_analog[8]}
N -560 -500 -390 -500 {
lab=io_analog[7]}
N -560 -340 -400 -340 {
lab=io_analog[6]}
N -560 -150 -400 -150 {
lab=io_analog[5]}
N -520 -250 -400 -250 {
lab=la_data_in[41]}
N -520 -440 -400 -440 {
lab=la_data_in[42]}
N -510 -600 -390 -600 {
lab=la_data_in[43]}
N -500 -750 -380 -750 {
lab=la_data_in[44]}
N -520 -910 -400 -910 {
lab=la_data_in[45]}
N -520 -1080 -400 -1080 {
lab=la_data_in[46]}
N -520 -1220 -400 -1220 {
lab=la_data_in[47]}
N 270 -1230 390 -1230 {
lab=la_data_in[48]}
N 270 -1080 390 -1080 {
lab=la_data_in[49]}
N 270 -750 390 -750 {
lab=la_data_in[51]}
N 270 -910 390 -910 {
lab=la_data_in[50]}
N 270 -600 390 -600 {
lab=la_data_in[52]}
N 270 -440 390 -440 {
lab=la_data_in[53]}
N 270 -260 390 -260 {
lab=la_data_in[54]}
N 270 -160 430 -160 {
lab=io_analog[0]}
N 270 -340 430 -340 {
lab=io_analog[1]}
N 270 -500 430 -500 {
lab=io_analog[2]}
N 270 -810 430 -810 {
lab=io_analog[3]}
N 270 -650 430 -650 {
lab=vdd_spare_1}
N 270 -980 430 -980 {
lab=vdd_spare_2}
N 270 -1130 430 -1130 {
lab=io_analog[4]}
N -570 -1250 -490 -1250 {
lab=vssd2}
N -490 -1160 -400 -1160 {
lab=vssd2}
N -470 -1140 -400 -1140 {
lab=vccd2}
N -490 -850 -400 -850 {
lab=vssd2}
N -490 -380 -490 -190 {
lab=vssd2}
N -490 -190 -400 -190 {
lab=vssd2}
N -440 190 -370 190 {
lab=vssd1}
N 370 180 420 180 {
lab=vssd2}
N 420 180 420 290 {
lab=vssd2}
N 480 220 510 220 {
lab=io_oeb[19]}
N 480 290 510 290 {
lab=io_oeb[20]}
N -20 190 50 190 {
lab=vssd2}
N -370 190 -370 540 {
lab=vssd1}
N -310 190 -280 190 {
lab=io_oeb[7]}
N -310 260 -280 260 {
lab=io_oeb[8]}
N -310 330 -280 330 {
lab=io_oeb[10]}
N -310 400 -280 400 {
lab=io_oeb[11]}
N -310 470 -280 470 {
lab=io_oeb[12]}
N -310 540 -280 540 {
lab=io_oeb[13]}
N 110 190 140 190 {
lab=io_oeb[14]}
N 110 260 140 260 {
lab=io_oeb[15]}
N 110 330 140 330 {
lab=io_oeb[16]}
N 110 400 140 400 {
lab=io_oeb[17]}
N 110 470 140 470 {
lab=io_oeb[18]}
N 50 190 50 470 {
lab=vssd2}
N -490 -1250 -490 -1210 {
lab=vssd2}
N -470 -1280 -470 -1260 {
lab=vccd2}
N 300 -1370 380 -1370 {
lab=vdda1}
N 300 -1340 300 -240 {
lab=vdda1}
N 270 -240 300 -240 {
lab=vdda1}
N 270 -420 300 -420 {
lab=vdda1}
N 270 -580 300 -580 {
lab=vdda1}
N 270 -890 300 -890 {
lab=vdda1}
N 270 -1060 300 -1060 {
lab=vdda1}
N 270 -1210 300 -1210 {
lab=vdda1}
N 300 -1370 300 -1340 {
lab=vdda1}
N 330 -1330 330 -1300 {
lab=vccd1}
N -520 -1370 -430 -1370 {
lab=vssa2}
N -430 -400 -400 -400 {
lab=vssa2}
N -430 -560 -390 -560 {
lab=vssa2}
N -430 -710 -380 -710 {
lab=vssa2}
N -430 -1040 -400 -1040 {
lab=vssa2}
N -430 -1180 -400 -1180 {
lab=vssa2}
N -450 -1200 -400 -1200 {
lab=vdda2}
N -450 -1060 -400 -1060 {
lab=vdda2}
N -450 -730 -380 -730 {
lab=vdda2}
N -450 -580 -390 -580 {
lab=vdda2}
N -450 -420 -400 -420 {
lab=vdda2}
N -450 -1330 -450 -420 {
lab=vdda2}
N -470 -360 -470 -170 {
lab=vccd2}
N -470 -170 -400 -170 {
lab=vccd2}
N -470 -230 -400 -230 {
lab=vccd2}
N -470 -830 -400 -830 {
lab=vccd2}
N -430 -1370 -430 -400 {
lab=vssa2}
N -490 -870 -400 -870 {
lab=vssd2}
N -470 -890 -400 -890 {
lab=vccd2}
N -490 -210 -400 -210 {
lab=vssd2}
N 350 -1300 380 -1300 {
lab=vssa1}
N 350 -1300 350 -220 {
lab=vssa1}
N 270 -220 350 -220 {
lab=vssa1}
N 270 -400 350 -400 {
lab=vssa1}
N 270 -560 350 -560 {
lab=vssa1}
N 270 -870 350 -870 {
lab=vssa1}
N 270 -1040 350 -1040 {
lab=vssa1}
N 270 -1190 350 -1190 {
lab=vssa1}
N 390 -1230 410 -1230 {
lab=la_data_in[48]}
N 430 -1130 450 -1130 {
lab=io_analog[4]}
N 430 -980 450 -980 {
lab=vdd_spare_2}
N 390 -1080 410 -1080 {
lab=la_data_in[49]}
N 390 -750 410 -750 {
lab=la_data_in[51]}
N 430 -650 450 -650 {
lab=vdd_spare_1}
N 390 -910 410 -910 {
lab=la_data_in[50]}
N 430 -810 450 -810 {
lab=io_analog[3]}
N 390 -600 410 -600 {
lab=la_data_in[52]}
N 430 -500 450 -500 {
lab=io_analog[2]}
N 390 -440 410 -440 {
lab=la_data_in[53]}
N 430 -340 450 -340 {
lab=io_analog[1]}
N 390 -260 410 -260 {
lab=la_data_in[54]}
N 430 -160 450 -160 {
lab=io_analog[0]}
N 360 -200 380 -200 {
lab=vssd1}
N 360 -380 380 -380 {
lab=vssd1}
N 360 -540 380 -540 {
lab=vssd1}
N 360 -850 380 -850 {
lab=vssd1}
N 360 -690 380 -690 {
lab=vssd1}
N 360 -1020 380 -1020 {
lab=vssd1}
N 360 -1170 380 -1170 {
lab=vssd1}
N 270 -730 330 -730 {
lab=vccd1}
N 270 -710 380 -710 {
lab=vssd1}
N -3920 -1030 -3830 -1030 {
lab=vccd2}
N -3920 -1000 -3830 -1000 {
lab=io_analog[9]}
N -3580 -1030 -3510 -1030 {
lab=vssd2}
N -3580 -1000 -3510 -1000 {
lab=vssd2}
N -3580 -940 -3510 -940 {
lab=vref_vbg}
N -3580 -910 -3510 -910 {
lab=vref_vbgsc}
N -3580 -880 -3510 -880 {
lab=vref_vbgtg}
N -3580 -850 -3510 -850 {
lab=vref_vptat}
N -3900 -940 -3830 -940 {
lab=la_oenb[29]}
N -3900 -970 -3830 -970 {
lab=la_oenb[27]}
N -3900 -910 -3830 -910 {
lab=la_data_in[29]}
N -3900 -880 -3830 -880 {
lab=la_oenb[28]}
N -3900 -850 -3830 -850 {
lab=la_data_in[28]}
N -3940 -630 -3850 -630 {
lab=vccd2}
N -3940 -610 -3850 -610 {
lab=vssd2}
N -3940 -590 -3850 -590 {
lab=io_analog[8]}
N -3940 -570 -3850 -570 {
lab=vssa2}
N -3940 -550 -3850 -550 {
lab=ccomp_vinp}
N -3940 -530 -3850 -530 {
lab=ccomp_vinm}
N -3940 -510 -3850 -510 {
lab=vssa2}
N -3550 -630 -3460 -630 {
lab=io_out[17]}
N -3950 -300 -3860 -300 {
lab=la_data_in[26]}
N -3950 -280 -3860 -280 {
lab=la_oenb[25]}
N -3950 -260 -3860 -260 {
lab=la_data_in[25]}
N -3950 -240 -3860 -240 {
lab=la_oenb[24]}
N -3950 -220 -3860 -220 {
lab=la_data_in[24]}
N -3950 -200 -3860 -200 {
lab=la_oenb[23]}
N -3950 -180 -3860 -180 {
lab=la_data_in[23]}
N -3950 -160 -3860 -160 {
lab=la_oenb[22]}
N -3950 -140 -3860 -140 {
lab=la_data_in[22]}
N -3950 -120 -3860 -120 {
lab=la_oenb[21]}
N -3950 -100 -3860 -100 {
lab=la_data_in[21]}
N -3950 -80 -3860 -80 {
lab=la_oenb[20]}
N -3950 -40 -3860 -40 {
lab=la_oenb[26]}
N -3560 -120 -3470 -120 {
lab=cdac_out}
N -3560 -100 -3470 -100 {
lab=#net1}
N -3560 -300 -3470 -300 {
lab=io_analog[7]}
N -3560 -280 -3470 -280 {
lab=vccd2}
N -3560 -260 -3470 -260 {
lab=vssd2}
N -3560 -240 -3470 -240 {
lab=vssa2}
N -3560 -220 -3470 -220 {
lab=cdac_vh}
N -3560 -200 -3470 -200 {
lab=cdac_vl}
N -3790 60 -3790 120 {
lab=io_analog[6]}
N -3840 60 -3790 60 {
lab=io_analog[6]}
N -3530 -1800 -3470 -1800 {
lab=vdd_spare_3}
N -3900 -1350 -3820 -1350 {
lab=io_analog[10]}
N -3900 -1330 -3820 -1330 {
lab=vssa2}
N -3900 -1310 -3820 -1310 {
lab=vccd2}
N -3900 -1290 -3820 -1290 {
lab=vssd2}
N -3900 -1270 -3820 -1270 {
lab=la_oenb[30]}
N -3900 -1250 -3820 -1250 {
lab=vbg}
N -3900 -1230 -3820 -1230 {
lab=la_data_in[30]}
N -3520 -1310 -3440 -1310 {
lab=ldo_vout}
N -3730 60 -3730 120 {
lab=vccd2}
N -3730 60 -3670 60 {
lab=vccd2}
N -3650 170 -3570 170 {
lab=io_out[21]}
N -3950 170 -3870 170 {
lab=la_data_in[20]}
N -3790 280 -3790 330 {
lab=vssa2}
N -3860 330 -3790 330 {
lab=vssa2}
N -3730 280 -3730 330 {
lab=vssd2}
N -3730 330 -3660 330 {
lab=vssd2}
N -3970 580 -3890 580 {
lab=io_analog[5]}
N -3970 680 -3890 680 {
lab=vssd2}
N -3970 600 -3890 600 {
lab=vccd2}
N -3970 620 -3890 620 {
lab=io_in[26]}
N -3970 640 -3890 640 {
lab=io_in[25]}
N -3590 580 -3510 580 {
lab=audio_out_p}
N -3590 600 -3510 600 {
lab=audio_out_n}
N -2660 -1910 -2660 -1850 {
lab=io_analog[4]}
N -2720 -1910 -2660 -1910 {
lab=io_analog[4]}
N -2600 -1910 -2600 -1850 {
lab=vccd1}
N -2600 -1910 -2550 -1910 {
lab=vccd1}
N -2660 -1690 -2660 -1650 {
lab=vssa1}
N -2700 -1650 -2660 -1650 {
lab=vssa1}
N -2600 -1690 -2600 -1650 {
lab=vssd1}
N -2600 -1650 -2560 -1650 {
lab=vssd1}
N -2520 -1800 -2460 -1800 {
lab=io_out[13]}
N -2790 -1800 -2740 -1800 {
lab=la_oenb[90]}
N -2480 -1490 -2410 -1490 {
lab=sample_out}
N -2850 -1490 -2780 -1490 {
lab=vccd1}
N -2850 -1470 -2780 -1470 {
lab=vdd_spare_2}
N -2850 -1450 -2780 -1450 {
lab=la_oenb[91]}
N -2850 -1430 -2780 -1430 {
lab=sample_in}
N -2850 -1410 -2780 -1410 {
lab=la_data_in[91]}
N -2850 -1390 -2780 -1390 {
lab=vssa1}
N -2850 -1370 -2780 -1370 {
lab=vssd1}
N -2510 -680 -2450 -680 {
lab=vdd_spare_1}
N -2510 -660 -2450 -660 {
lab=vssd1}
N -2660 -1210 -2660 -1150 {
lab=io_analog[3]}
N -2720 -1210 -2660 -1210 {
lab=io_analog[3]}
N -2620 -1210 -2620 -1150 {
lab=vccd1}
N -2620 -1210 -2570 -1210 {
lab=vccd1}
N -2520 -1050 -2450 -1050 {
lab=io_out[10]}
N -2620 -950 -2620 -900 {
lab=vssd1}
N -2620 -900 -2550 -900 {
lab=vssd1}
N -2660 -950 -2660 -900 {
lab=vssa1}
N -2720 -900 -2660 -900 {
lab=vssa1}
N -2840 -1090 -2760 -1090 {
lab=ulpcomp_vinp}
N -2840 -1060 -2760 -1060 {
lab=ulpcomp_vinn}
N -2840 -1010 -2760 -1010 {
lab=la_data_in[107]}
N -2840 -990 -2760 -990 {
lab=la_oenb[106]}
N -2800 180 -2730 180 {
lab=io_analog[2]}
N -2800 200 -2730 200 {
lab=vccd1}
N -2800 220 -2730 220 {
lab=vssa1}
N -2800 240 -2730 240 {
lab=vssd1}
N -2800 260 -2730 260 {
lab=vbg}
N -2570 200 -2500 200 {
lab=io_out[7]}
N -2570 220 -2500 220 {
lab=io_out[8]}
N -2570 240 -2500 240 {
lab=por_outh[1:0]}
N -2910 380 -2840 380 {
lab=io_analog[1]}
N -2900 840 -2830 840 {
lab=io_analog[0]}
N -2910 400 -2840 400 {
lab=vccd1}
N -2900 860 -2830 860 {
lab=vccd1}
N -2910 440 -2840 440 {
lab=la_oenb[107]}
N -2910 460 -2840 460 {
lab=la_data_in[108]}
N -2910 480 -2840 480 {
lab=la_oenb[108]}
N -2910 500 -2840 500 {
lab=la_data_in[109]}
N -2910 520 -2840 520 {
lab=la_oenb[109]}
N -2910 540 -2840 540 {
lab=la_data_in[110]}
N -2910 560 -2840 560 {
lab=la_oenb[110]}
N -2910 580 -2840 580 {
lab=la_data_in[111]}
N -2540 380 -2470 380 {
lab=rheostat_vh}
N -2540 640 -2470 640 {
lab=rheostat_vl}
N -2910 620 -2840 620 {
lab=vssd1}
N -2910 640 -2840 640 {
lab=vssa1}
N -2900 880 -2830 880 {
lab=la_oenb[115]}
N -2900 900 -2830 900 {
lab=la_oenb[111]}
N -2900 920 -2830 920 {
lab=la_data_in[112]}
N -2900 940 -2830 940 {
lab=la_oenb[112]}
N -2900 960 -2830 960 {
lab=la_data_in[113]}
N -2900 980 -2830 980 {
lab=la_oenb[113]}
N -2900 1000 -2830 1000 {
lab=la_data_in[114]}
N -2900 1020 -2830 1020 {
lab=la_oenb[114]}
N -2900 1040 -2830 1040 {
lab=la_data_in[115]}
N -2900 1080 -2830 1080 {
lab=vssd1}
N -2900 1100 -2830 1100 {
lab=vssa1}
N -2530 1100 -2460 1100 {
lab=rdac_vl}
N -2530 970 -2460 970 {
lab=rdac_out}
N -2530 840 -2460 840 {
lab=rdac_vh}
N -2540 510 -2470 510 {
lab=rheostat_out}
N -3530 -1840 -3470 -1840 {
lab=vccd2}
N -3530 -1820 -3470 -1820 {
lab=vssd2}
N -3530 -1780 -3470 -1780 {
lab=vssa2}
N -3530 -1740 -3470 -1740 {
lab=idac_src_out}
N -3530 -1720 -3470 -1720 {
lab=idac_snk_out}
N -3890 -1720 -3830 -1720 {
lab=la_data_in[31],la_oenb[31],la_data_in[32],la_oenb[32],la_data_in[33],la_oenb[33],la_data_in[34],la_oenb[34]}
N -3890 -1840 -3830 -1840 {
lab=la_oenb[35]}
N -3890 -1820 -3830 -1820 {
lab=idac_ref_in}
N -3890 -1800 -3830 -1800 {
lab=vbg}
N -3890 -1780 -3830 -1780 {
lab=la_data_in[35]}
N -2890 -700 -2810 -700 {
lab=la_oenb[95]}
N -2890 -680 -2810 -680 {
lab=la_data_in[96]}
N -2890 -640 -2810 -640 {
lab=la_data_in[95]}
N -2890 -620 -2810 -620 {
lab=la_oenb[96]}
N -2890 -580 -2810 -580 {
lab=la_oenb[94]}
N -2890 -560 -2810 -560 {
lab=la_data_in[97]}
N -2890 -540 -2810 -540 {
lab=la_data_in[94]}
N -2890 -520 -2810 -520 {
lab=la_oenb[97]}
N -2890 -500 -2810 -500 {
lab=pll_fin}
N -2890 -600 -2810 -600 {
lab=la_oenb[102]}
N -2890 -660 -2810 -660 {
lab=la_oenb[103]}
N -2510 -640 -2430 -640 {
lab=io_out[20]}
N -2510 -620 -2430 -620 {
lab=io_out[11]}
N -2510 -580 -2430 -580 {
lab=io_out[15]}
N -2510 -560 -2430 -560 {
lab=io_out[16]}
N -2510 -520 -2430 -520 {
lab=io_out[19]}
N -2510 -500 -2430 -500 {
lab=io_out[18]}
N -2510 -540 -2430 -540 {
lab=io_out[14]}
N -2510 -600 -2430 -600 {
lab=io_out[12]}
N -2890 -480 -2810 -480 {
lab=la_oenb[93]}
N -2890 -460 -2810 -460 {
lab=la_data_in[98]}
N -2890 -420 -2810 -420 {
lab=la_oenb[98]}
N -2890 -400 -2810 -400 {
lab=la_data_in[104]}
N -2890 -360 -2810 -360 {
lab=la_data_in[99]}
N -2890 -340 -2810 -340 {
lab=pll_vctrl_in}
N -2890 -320 -2810 -320 {
lab=la_oenb[104]}
N -2890 -280 -2810 -280 {
lab=la_data_in[102]}
N -2890 -380 -2810 -380 {
lab=la_data_in[103]}
N -2890 -440 -2810 -440 {
lab=pll_ibias}
N -2890 -260 -2810 -260 {
lab=la_data_in[105]}
N -2890 -240 -2810 -240 {
lab=la_oenb[101]}
N -2890 -200 -2810 -200 {
lab=la_data_in[101]}
N -2890 -180 -2810 -180 {
lab=pll_lf}
N -2890 -140 -2810 -140 {
lab=la_oenb[100]}
N -2890 -120 -2810 -120 {
lab=la_data_in[100]}
N -2890 -60 -2810 -60 {
lab=la_data_in[93]}
N -2890 -160 -2810 -160 {
lab=la_data_in[106]}
N -2890 -220 -2810 -220 {
lab=la_oenb[105]}
N -2890 -40 -2810 -40 {
lab=la_oenb[92]}
N -2890 -20 -2810 -20 {
lab=la_data_in[92]}
N -4830 -1530 -4770 -1530 {
lab=gpio_noesd[7]}
N -4830 -1530 -4830 -1490 {
lab=gpio_noesd[7]}
N -4830 -1490 -4770 -1490 {
lab=gpio_noesd[7]}
N -4900 -1490 -4830 -1490 {
lab=gpio_noesd[7]}
N -4870 -1510 -4770 -1510 {
lab=vref_vptat}
N -4870 -1550 -4770 -1550 {
lab=idac_src_out}
N -4870 -1590 -4770 -1590 {
lab=vssa2}
N -4870 -1610 -4770 -1610 {
lab=vssd2}
N -4870 -1630 -4770 -1630 {
lab=vccd2}
N -4870 -1650 -4770 -1650 {
lab=vdda2}
N -4470 -1540 -4430 -1540 {
lab=la_data_in[18],la_oenb[18]}
N -4470 -1500 -4430 -1500 {
lab=la_data_in[19],la_oenb[19]}
N -4830 -1290 -4770 -1290 {
lab=gpio_noesd[8]}
N -4830 -1290 -4830 -1250 {
lab=gpio_noesd[8]}
N -4830 -1250 -4770 -1250 {
lab=gpio_noesd[8]}
N -4900 -1250 -4830 -1250 {
lab=gpio_noesd[8]}
N -4870 -1270 -4770 -1270 {
lab=vref_vbg}
N -4870 -1310 -4770 -1310 {
lab=idac_snk_out}
N -4870 -1350 -4770 -1350 {
lab=vssa2}
N -4870 -1370 -4770 -1370 {
lab=vssd2}
N -4870 -1390 -4770 -1390 {
lab=vccd2}
N -4870 -1410 -4770 -1410 {
lab=vdda2}
N -4470 -1300 -4430 -1300 {
lab=la_data_in[16],la_oenb[16]}
N -4470 -1260 -4430 -1260 {
lab=la_data_in[17],la_oenb[17]}
N -4820 -1050 -4760 -1050 {
lab=gpio_noesd[9]}
N -4820 -1050 -4820 -1010 {
lab=gpio_noesd[9]}
N -4820 -1010 -4760 -1010 {
lab=gpio_noesd[9]}
N -4890 -1010 -4820 -1010 {
lab=gpio_noesd[9]}
N -4860 -1030 -4760 -1030 {
lab=vref_vbgsc}
N -4860 -1070 -4760 -1070 {
lab=ldo_vout}
N -4860 -1110 -4760 -1110 {
lab=vssa2}
N -4860 -1130 -4760 -1130 {
lab=vssd2}
N -4860 -1150 -4760 -1150 {
lab=vccd2}
N -4860 -1170 -4760 -1170 {
lab=vdda2}
N -4460 -1060 -4420 -1060 {
lab=la_data_in[14],la_oenb[14]}
N -4460 -1020 -4420 -1020 {
lab=la_data_in[15],la_oenb[15]}
N -4820 -810 -4760 -810 {
lab=gpio_noesd[10]}
N -4820 -810 -4820 -770 {
lab=gpio_noesd[10]}
N -4820 -770 -4760 -770 {
lab=gpio_noesd[10]}
N -4890 -770 -4820 -770 {
lab=gpio_noesd[10]}
N -4860 -790 -4760 -790 {
lab=vref_vbgtg}
N -4860 -830 -4760 -830 {
lab=idac_ref_in}
N -4860 -870 -4760 -870 {
lab=vssa2}
N -4860 -890 -4760 -890 {
lab=vssd2}
N -4860 -910 -4760 -910 {
lab=vccd2}
N -4860 -930 -4760 -930 {
lab=vdda2}
N -4460 -820 -4420 -820 {
lab=la_data_in[12],la_oenb[12]}
N -4460 -780 -4420 -780 {
lab=la_data_in[13],la_oenb[13]}
N -4820 -570 -4760 -570 {
lab=gpio_noesd[11]}
N -4820 -570 -4820 -530 {
lab=gpio_noesd[11]}
N -4820 -530 -4760 -530 {
lab=gpio_noesd[11]}
N -4890 -530 -4820 -530 {
lab=gpio_noesd[11]}
N -4860 -550 -4760 -550 {
lab=cdac_vh}
N -4860 -590 -4760 -590 {
lab=ccomp_vinp}
N -4860 -630 -4760 -630 {
lab=vssa2}
N -4860 -650 -4760 -650 {
lab=vssd2}
N -4860 -670 -4760 -670 {
lab=vccd2}
N -4860 -690 -4760 -690 {
lab=vdda2}
N -4460 -580 -4420 -580 {
lab=la_data_in[10],la_oenb[10]}
N -4460 -540 -4420 -540 {
lab=la_data_in[11],la_oenb[11]}
N -4820 -320 -4760 -320 {
lab=gpio_noesd[12]}
N -4820 -320 -4820 -280 {
lab=gpio_noesd[12]}
N -4820 -280 -4760 -280 {
lab=gpio_noesd[12]}
N -4890 -280 -4820 -280 {
lab=gpio_noesd[12]}
N -4860 -300 -4760 -300 {
lab=cdac_vl}
N -4860 -340 -4760 -340 {
lab=ccomp_vinm}
N -4860 -380 -4760 -380 {
lab=vssa2}
N -4860 -400 -4760 -400 {
lab=vssd2}
N -4860 -420 -4760 -420 {
lab=vccd2}
N -4860 -440 -4760 -440 {
lab=vdda2}
N -4460 -330 -4420 -330 {
lab=la_data_in[8],la_oenb[8]}
N -4460 -290 -4420 -290 {
lab=la_data_in[9],la_oenb[9]}
N -4820 -90 -4760 -90 {
lab=gpio_noesd[13]}
N -4820 -90 -4820 -50 {
lab=gpio_noesd[13]}
N -4820 -50 -4760 -50 {
lab=gpio_noesd[13]}
N -4890 -50 -4820 -50 {
lab=gpio_noesd[13]}
N -4860 -70 -4760 -70 {
lab=cdac_out}
N -4860 -110 -4760 -110 {
lab=pll_fin}
N -4860 -150 -4760 -150 {
lab=vssa2}
N -4860 -170 -4760 -170 {
lab=vssd2}
N -4860 -190 -4760 -190 {
lab=vccd2}
N -4860 -210 -4760 -210 {
lab=vdda2}
N -4460 -100 -4420 -100 {
lab=la_data_in[6],la_oenb[6]}
N -4460 -60 -4420 -60 {
lab=la_data_in[7],la_oenb[7]}
N -4810 150 -4750 150 {
lab=gpio_noesd[14]}
N -4810 150 -4810 190 {
lab=gpio_noesd[14]}
N -4810 190 -4750 190 {
lab=gpio_noesd[14]}
N -4880 190 -4810 190 {
lab=gpio_noesd[14]}
N -4850 170 -4750 170 {
lab=#net2}
N -4850 130 -4750 130 {
lab=pll_ibias}
N -4850 90 -4750 90 {
lab=vssa2}
N -4850 70 -4750 70 {
lab=vssd2}
N -4850 50 -4750 50 {
lab=vccd2}
N -4850 30 -4750 30 {
lab=vdda2}
N -4450 140 -4410 140 {
lab=la_data_in[4],la_oenb[4]}
N -4450 180 -4410 180 {
lab=la_data_in[5],la_oenb[5]}
N -4810 370 -4750 370 {
lab=gpio_noesd[15]}
N -4810 370 -4810 410 {
lab=gpio_noesd[15]}
N -4810 410 -4750 410 {
lab=gpio_noesd[15]}
N -4880 410 -4810 410 {
lab=gpio_noesd[15]}
N -4850 390 -4750 390 {
lab=audio_out_n}
N -4850 350 -4750 350 {
lab=pll_vctrl_in}
N -4850 310 -4750 310 {
lab=vssa2}
N -4850 290 -4750 290 {
lab=vssd2}
N -4850 270 -4750 270 {
lab=vccd2}
N -4850 250 -4750 250 {
lab=vdda2}
N -4450 360 -4410 360 {
lab=la_data_in[2],la_oenb[2]}
N -4450 400 -4410 400 {
lab=la_data_in[3],la_oenb[3]}
N -4810 600 -4750 600 {
lab=gpio_noesd[16]}
N -4810 600 -4810 640 {
lab=gpio_noesd[16]}
N -4810 640 -4750 640 {
lab=gpio_noesd[16]}
N -4880 640 -4810 640 {
lab=gpio_noesd[16]}
N -4850 620 -4750 620 {
lab=audio_out_p}
N -4850 580 -4750 580 {
lab=#net3}
N -4850 540 -4750 540 {
lab=vssa2}
N -4850 520 -4750 520 {
lab=vssd2}
N -4850 500 -4750 500 {
lab=vccd2}
N -4850 480 -4750 480 {
lab=vdda2}
N -4450 590 -4410 590 {
lab=la_data_in[0],la_oenb[0]}
N -4450 630 -4410 630 {
lab=la_data_in[1],la_oenb[1]}
N -4810 880 -4750 880 {
lab=gpio_analog[17]}
N -4880 880 -4810 880 {
lab=gpio_analog[17]}
N -1570 -1530 -1500 -1530 {
lab=gpio_noesd[6]}
N -1570 -1550 -1470 -1550 {
lab=ulpcomp_vinn}
N -1570 -1590 -1470 -1590 {
lab=sample_out}
N -1570 -1630 -1470 -1630 {
lab=vssa1}
N -1570 -1650 -1470 -1650 {
lab=vssd1}
N -1570 -1670 -1470 -1670 {
lab=vccd1}
N -1570 -1690 -1470 -1690 {
lab=vdda1}
N -1910 -1580 -1870 -1580 {
lab=la_oenb[117],la_data_in[117]}
N -1910 -1540 -1870 -1540 {
lab=la_oenb[116],la_data_in[116]}
N -1570 -1290 -1500 -1290 {
lab=gpio_noesd[5]}
N -1570 -1310 -1470 -1310 {
lab=por_outh[1]}
N -1570 -1350 -1470 -1350 {
lab=sample_in}
N -1570 -1390 -1470 -1390 {
lab=vssa1}
N -1570 -1410 -1470 -1410 {
lab=vssd1}
N -1570 -1430 -1470 -1430 {
lab=vccd1}
N -1570 -1450 -1470 -1450 {
lab=vdda1}
N -1910 -1340 -1870 -1340 {
lab=la_oenb[119],la_data_in[119]}
N -1910 -1300 -1870 -1300 {
lab=la_oenb[118],la_data_in[118]}
N -1560 -1050 -1490 -1050 {
lab=gpio_noesd[4]}
N -1560 -1070 -1460 -1070 {
lab=pll_lf}
N -1560 -1110 -1460 -1110 {
lab=ulpcomp_vinp}
N -1560 -1150 -1460 -1150 {
lab=vssa1}
N -1560 -1170 -1460 -1170 {
lab=vssd1}
N -1560 -1190 -1460 -1190 {
lab=vccd1}
N -1560 -1210 -1460 -1210 {
lab=vdda1}
N -1900 -1100 -1860 -1100 {
lab=la_oenb[121],la_data_in[121]}
N -1900 -1060 -1860 -1060 {
lab=la_oenb[120],la_data_in[120]}
N -1560 -810 -1490 -810 {
lab=gpio_noesd[3]}
N -1560 -830 -1460 -830 {
lab=rheostat_vh}
N -1560 -870 -1460 -870 {
lab=rdac_vh}
N -1560 -910 -1460 -910 {
lab=vssa1}
N -1560 -930 -1460 -930 {
lab=vssd1}
N -1560 -950 -1460 -950 {
lab=vccd1}
N -1560 -970 -1460 -970 {
lab=vdda1}
N -1900 -860 -1860 -860 {
lab=la_oenb[123],la_data_in[123]}
N -1900 -820 -1860 -820 {
lab=la_oenb[122],la_data_in[122]}
N -1560 -320 -1490 -320 {
lab=gpio_noesd[1]}
N -1560 -340 -1460 -340 {
lab=rheostat_vl}
N -1560 -380 -1460 -380 {
lab=rdac_vl}
N -1560 -420 -1460 -420 {
lab=vssa1}
N -1560 -440 -1460 -440 {
lab=vssd1}
N -1560 -460 -1460 -460 {
lab=vccd1}
N -1560 -480 -1460 -480 {
lab=vdda1}
N -1900 -370 -1860 -370 {
lab=la_oenb[125],la_data_in[125]}
N -1900 -330 -1860 -330 {
lab=la_oenb[124],la_data_in[124]}
N -1560 -90 -1490 -90 {
lab=gpio_noesd[0]}
N -1560 -150 -1460 -150 {
lab=rheostat_out}
N -1560 -190 -1460 -190 {
lab=vssa1}
N -1560 -210 -1460 -210 {
lab=vssd1}
N -1560 -230 -1460 -230 {
lab=vccd1}
N -1560 -250 -1460 -250 {
lab=vdda1}
N -1900 -140 -1860 -140 {
lab=la_oenb[127],la_data_in[127]}
N -1900 -100 -1860 -100 {
lab=la_oenb[126],la_data_in[126]}
N -1560 -110 -1460 -110 {
lab=rdac_out}
N -1560 -130 -1460 -130 {
lab=gpio_noesd[0]}
N -1490 -130 -1490 -90 {
lab=gpio_noesd[0]}
N -1560 -360 -1460 -360 {
lab=gpio_noesd[1]}
N -1490 -360 -1490 -320 {
lab=gpio_noesd[1]}
N -1560 -850 -1460 -850 {
lab=gpio_noesd[3]}
N -1490 -850 -1490 -810 {
lab=gpio_noesd[3]}
N -1560 -1090 -1460 -1090 {
lab=gpio_noesd[4]}
N -1490 -1090 -1490 -1050 {
lab=gpio_noesd[4]}
N -1570 -1330 -1470 -1330 {
lab=gpio_noesd[5]}
N -1500 -1330 -1500 -1290 {
lab=gpio_noesd[5]}
N -1570 -1570 -1470 -1570 {
lab=gpio_noesd[6]}
N -1500 -1570 -1500 -1530 {
lab=gpio_noesd[6]}
N -3940 -490 -3850 -490 {
lab=la_data_in[27]}
N -1750 110 -1680 110 {
lab=rheostat_vh}
N -1620 110 -1550 110 {
lab=io_in_3v3[5]}
N -1750 240 -1680 240 {
lab=rheostat_vl}
N -1620 240 -1550 240 {
lab=#net4}
N -1750 360 -1680 360 {
lab=rdac_vh}
N -1620 360 -1550 360 {
lab=io_in_3v3[3]}
N -1750 480 -1680 480 {
lab=rdac_vl}
N -1620 480 -1550 480 {
lab=io_in_3v3[4]}
N -4690 880 -4590 880 {
lab=vbg}
N 480 390 510 390 {
lab=io_oeb[21]}
N 420 290 420 390 {
lab=vssd2}
C {power_stage.sym} -250 -1170 0 0 {name=x2}
C {power_stage.sym} -250 -1030 0 0 {name=x3}
C {power_stage.sym} -250 -860 0 0 {name=x4}
C {power_stage.sym} -230 -700 0 0 {name=x5}
C {power_stage.sym} -240 -550 0 0 {name=x6}
C {power_stage.sym} -250 -390 0 0 {name=x7}
C {power_stage.sym} -250 -200 0 0 {name=x8}
C {power_stage.sym} 120 -1180 0 1 {name=x9}
C {power_stage.sym} 120 -1030 0 1 {name=x10}
C {power_stage.sym} 120 -700 0 1 {name=x11}
C {power_stage.sym} 120 -860 0 1 {name=x12}
C {power_stage.sym} 120 -550 0 1 {name=x13}
C {power_stage.sym} 120 -390 0 1 {name=x14}
C {power_stage.sym} 120 -210 0 1 {name=x15}
C {devices/ipin.sym} 380 -1370 0 1 {name=p1 lab=vdda1}
C {devices/ipin.sym} 380 -1300 0 1 {name=p2 lab=vssa1}
C {devices/ipin.sym} -500 -1280 0 0 {name=p3 lab=vccd2}
C {devices/ipin.sym} -500 -1330 0 0 {name=p4 lab=vdda2}
C {devices/ipin.sym} -520 -1370 0 0 {name=p6 lab=vssa2}
C {devices/lab_pin.sym} -580 -1120 0 0 {name=p35 sig_type=std_logic lab=vdd_spare_3}
C {devices/lab_pin.sym} 450 -650 0 1 {name=p46 sig_type=std_logic lab=vdd_spare_1}
C {devices/lab_pin.sym} 450 -980 0 1 {name=p47 sig_type=std_logic lab=vdd_spare_2}
C {devices/iopin.sym} -3680 940 0 1 {name=p214 lab=gpio_noesd[17:0]}
C {devices/iopin.sym} -3680 960 0 1 {name=p228 lab=gpio_analog[17:0]}
C {devices/ipin.sym} -3670 1020 0 0 {name=p268 lab=la_data_in[127:0]}
C {devices/opin.sym} -3800 910 0 0 {name=p272 lab=io_out[26:0]}
C {devices/opin.sym} -3850 1080 0 0 {name=p277 lab=la_data_out[127:0]}
C {devices/opin.sym} -3800 890 0 0 {name=p300 lab=io_oeb[26:0]}
C {devices/iopin.sym} -3680 990 0 1 {name=p36 lab=io_analog[10:0]}
C {devices/lab_pin.sym} -20 190 0 0 {name=p316 sig_type=std_logic lab=vssd2}
C {devices/ipin.sym} -570 -1250 0 0 {name=p325 lab=vssd2}
C {devices/ipin.sym} 420 -1260 0 1 {name=p326 lab=vssd1}
C {devices/lab_pin.sym} 510 220 0 1 {name=p348 sig_type=std_logic lab=io_oeb[19]}
C {devices/lab_pin.sym} 510 290 0 1 {name=p349 sig_type=std_logic lab=io_oeb[20]
]}
C {devices/lab_pin.sym} -520 -1080 0 0 {name=p418 sig_type=std_logic lab=la_data_in[46]}
C {devices/lab_pin.sym} -520 -250 0 0 {name=p420 sig_type=std_logic lab=la_data_in[41]}
C {devices/lab_pin.sym} -520 -440 0 0 {name=p422 sig_type=std_logic lab=la_data_in[42]}
C {devices/lab_pin.sym} -510 -600 0 0 {name=p424 sig_type=std_logic lab=la_data_in[43]}
C {devices/lab_pin.sym} -500 -750 0 0 {name=p426 sig_type=std_logic lab=la_data_in[44]}
C {devices/lab_pin.sym} -520 -910 0 0 {name=p428 sig_type=std_logic lab=la_data_in[45]}
C {devices/lab_pin.sym} -520 -1220 0 0 {name=p430 sig_type=std_logic lab=la_data_in[47]}
C {devices/lab_pin.sym} 410 -1230 0 1 {name=p431 sig_type=std_logic lab=la_data_in[48]}
C {devices/lab_pin.sym} 410 -1080 0 1 {name=p435 sig_type=std_logic lab=la_data_in[49]}
C {devices/lab_pin.sym} 410 -910 0 1 {name=p437 sig_type=std_logic lab=la_data_in[50]}
C {devices/lab_pin.sym} 410 -750 0 1 {name=p439 sig_type=std_logic lab=la_data_in[51]}
C {devices/lab_pin.sym} 410 -600 0 1 {name=p441 sig_type=std_logic lab=la_data_in[52]}
C {devices/lab_pin.sym} 410 -440 0 1 {name=p443 sig_type=std_logic lab=la_data_in[53]}
C {devices/lab_pin.sym} -580 -980 0 0 {name=p445 sig_type=std_logic lab=io_analog[10]}
C {devices/lab_pin.sym} -570 -810 0 0 {name=p446 sig_type=std_logic lab=io_analog[9]}
C {devices/lab_pin.sym} -570 -650 0 0 {name=p447 sig_type=std_logic lab=io_analog[8]}
C {devices/lab_pin.sym} -560 -500 0 0 {name=p448 sig_type=std_logic lab=io_analog[7]}
C {devices/lab_pin.sym} -560 -340 0 0 {name=p449 sig_type=std_logic lab=io_analog[6]}
C {devices/lab_pin.sym} -560 -150 0 0 {name=p450 sig_type=std_logic lab=io_analog[5]}
C {devices/lab_pin.sym} 450 -160 0 1 {name=p451 sig_type=std_logic lab=io_analog[0]}
C {devices/lab_pin.sym} 450 -340 0 1 {name=p452 sig_type=std_logic lab=io_analog[1]}
C {devices/lab_pin.sym} 450 -500 0 1 {name=p453 sig_type=std_logic lab=io_analog[2]}
C {devices/lab_pin.sym} 450 -1130 0 1 {name=p454 sig_type=std_logic lab=io_analog[4]}
C {devices/ipin.sym} 380 -1330 0 1 {name=p455 lab=vccd1}
C {devices/lab_pin.sym} 140 190 0 1 {name=p7 sig_type=std_logic lab=io_oeb[14]}
C {devices/lab_pin.sym} 140 260 0 1 {name=p8 sig_type=std_logic lab=io_oeb[15]}
C {devices/lab_pin.sym} 140 330 0 1 {name=p9 sig_type=std_logic lab=io_oeb[16]}
C {devices/lab_pin.sym} 140 400 0 1 {name=p10 sig_type=std_logic lab=io_oeb[17]}
C {devices/lab_pin.sym} 140 470 0 1 {name=p11 sig_type=std_logic lab=io_oeb[18]}
C {devices/lab_pin.sym} -280 190 0 1 {name=p12 sig_type=std_logic lab=io_oeb[7]}
C {devices/lab_pin.sym} -280 260 0 1 {name=p13 sig_type=std_logic lab=io_oeb[8]}
C {devices/lab_pin.sym} -280 330 0 1 {name=p14 sig_type=std_logic lab=io_oeb[10]}
C {devices/lab_pin.sym} -280 400 0 1 {name=p15 sig_type=std_logic lab=io_oeb[11]}
C {devices/lab_pin.sym} -280 470 0 1 {name=p16 sig_type=std_logic lab=io_oeb[12]}
C {devices/lab_pin.sym} -280 540 0 1 {name=p17 sig_type=std_logic lab=io_oeb[13]}
C {devices/lab_pin.sym} 450 -810 0 1 {name=p18 sig_type=std_logic lab=io_analog[3]}
C {devices/lab_pin.sym} -440 190 0 0 {name=p19 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} 370 180 0 0 {name=p21 sig_type=std_logic lab=vssd2}
C {sky130_fd_pr/res_generic_m3.sym} -340 190 1 0 {name=R1
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -340 260 1 0 {name=R2
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -340 330 1 0 {name=R3
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -340 400 1 0 {name=R4
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -340 470 1 0 {name=R5
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -340 540 1 0 {name=R6
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} 80 190 1 0 {name=R7
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} 80 260 1 0 {name=R8
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} 80 330 1 0 {name=R9
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} 80 400 1 0 {name=R10
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} 80 470 1 0 {name=R11
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} 450 220 1 0 {name=R12
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} 450 290 1 0 {name=R13
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_ef_ip__rheostat_8bit.sym} -2690 510 0 0 {name=x16}
C {sky130_ef_ip__samplehold.sym} -2630 -1430 0 0 {name=x18}
C {sky130_ef_ip__cdac3v_12bit.sym} -3710 -180 0 0 {name=x19}
C {sky130_icrg_ip__ulpcomp2.sym} -2980 -920 0 0 {name=x20}
C {sky130_ak_ip__cmos_vref.sym} -3700 -940 0 0 {name=X21}
C {sky130_ef_ip__rc_osc_16M.sym} -3760 200 0 0 {name=x22}
C {sky130_iic_ip__audiodac_drv_lite.sym} -3740 630 0 0 {name=x23}
C {sky130_am_ip__ldo_01v8.sym} -3670 -1270 0 0 {name=x24}
C {sky130_ef_ip__rc_osc_500k.sym} -2630 -1770 0 0 {name=x25}
C {sky130_sw_ip__bgrref_por.sym} -2650 220 0 0 {name=x26}
C {sky130_ef_ip__rdac3v_8bit.sym} -2680 970 0 0 {name=x27}
C {sky130_ef_ip__idac3v_8bit.sym} -3680 -1790 0 0 {name=x29}
C {devices/lab_pin.sym} -3920 -1000 0 0 {name=p23 sig_type=std_logic lab=io_analog[9]}
C {devices/lab_pin.sym} -3920 -1030 0 0 {name=p22 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -3510 -1030 0 1 {name=p24 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -3510 -1000 0 1 {name=p25 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -3940 -630 0 0 {name=p26 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -3940 -610 0 0 {name=p27 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -3940 -570 0 0 {name=p28 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} -3940 -590 0 0 {name=p29 sig_type=std_logic lab=io_analog[8]}
C {devices/noconn.sym} -3470 -100 0 1 {name=l1}
C {devices/lab_pin.sym} -3470 -300 0 1 {name=p30 sig_type=std_logic lab=io_analog[7]}
C {devices/lab_pin.sym} -3470 -280 0 1 {name=p31 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -3470 -260 0 1 {name=p32 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -3470 -240 0 1 {name=p33 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} -3470 -1800 0 1 {name=p34 sig_type=std_logic lab=vdd_spare_3}
C {devices/lab_pin.sym} -3900 -1350 0 0 {name=p37 sig_type=std_logic lab=io_analog[10]}
C {devices/lab_pin.sym} -3900 -1330 0 0 {name=p38 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} -3900 -1310 0 0 {name=p39 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -3900 -1290 0 0 {name=p40 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -3840 60 0 0 {name=p41 sig_type=std_logic lab=io_analog[6]}
C {devices/lab_pin.sym} -3670 60 0 1 {name=p42 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -3860 330 0 0 {name=p43 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} -3660 330 0 1 {name=p44 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -3970 580 0 0 {name=p45 sig_type=std_logic lab=io_analog[5]}
C {devices/lab_pin.sym} -3970 680 0 0 {name=p48 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -2720 -1910 0 0 {name=p49 sig_type=std_logic lab=io_analog[4]}
C {devices/lab_pin.sym} -2550 -1910 0 1 {name=p50 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -2560 -1650 0 1 {name=p51 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -2700 -1650 0 0 {name=p52 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} -2850 -1470 0 0 {name=p53 sig_type=std_logic lab=vdd_spare_2}
C {devices/lab_pin.sym} -2850 -1490 0 0 {name=p54 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -2850 -1390 0 0 {name=p55 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} -2850 -1370 0 0 {name=p56 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -2720 -1210 0 0 {name=p57 sig_type=std_logic lab=io_analog[3]}
C {devices/lab_pin.sym} -2450 -660 0 1 {name=p58 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -2450 -680 0 1 {name=p59 sig_type=std_logic lab=vdd_spare_1}
C {devices/lab_pin.sym} -2570 -1210 0 1 {name=p60 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -2550 -900 0 1 {name=p61 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -2720 -900 0 0 {name=p62 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} -2800 180 0 0 {name=p63 sig_type=std_logic lab=io_analog[2]}
C {devices/lab_pin.sym} -2800 240 0 0 {name=p64 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -2800 200 0 0 {name=p65 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -2800 220 0 0 {name=p66 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} -2910 380 0 0 {name=p67 sig_type=std_logic lab=io_analog[1]}
C {devices/lab_pin.sym} -2900 840 0 0 {name=p68 sig_type=std_logic lab=io_analog[0]}
C {devices/lab_pin.sym} -2910 400 0 0 {name=p69 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -2900 860 0 0 {name=p72 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -2910 620 0 0 {name=p73 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -2900 1080 0 0 {name=p74 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -2910 640 0 0 {name=p75 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} -2900 1100 0 0 {name=p76 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} -3470 -1840 0 1 {name=p77 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -3470 -1820 0 1 {name=p78 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -3470 -1780 0 1 {name=p79 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} -3890 -1800 0 0 {name=p5 sig_type=std_logic lab=vbg}
C {devices/lab_pin.sym} -3900 -1250 0 0 {name=p20 sig_type=std_logic lab=vbg}
C {devices/lab_pin.sym} -3970 600 0 0 {name=p70 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -2800 260 0 0 {name=p71 sig_type=std_logic lab=vbg}
C {switch_array_2.sym} -4620 -1540 0 1 {name=x1}
C {devices/lab_pin.sym} -4900 -1490 0 0 {name=p80 sig_type=std_logic lab=gpio_noesd[7]}
C {devices/lab_pin.sym} -4870 -1650 0 0 {name=p81 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4870 -1630 0 0 {name=p82 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4870 -1610 0 0 {name=p83 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4870 -1590 0 0 {name=p84 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4620 -1300 0 1 {name=x30}
C {devices/lab_pin.sym} -4900 -1250 0 0 {name=p85 sig_type=std_logic lab=gpio_noesd[8]}
C {devices/lab_pin.sym} -4870 -1410 0 0 {name=p86 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4870 -1390 0 0 {name=p87 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4870 -1370 0 0 {name=p88 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4870 -1350 0 0 {name=p89 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4610 -1060 0 1 {name=x31}
C {devices/lab_pin.sym} -4890 -1010 0 0 {name=p90 sig_type=std_logic lab=gpio_noesd[9]}
C {devices/lab_pin.sym} -4860 -1170 0 0 {name=p91 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4860 -1150 0 0 {name=p92 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4860 -1130 0 0 {name=p93 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4860 -1110 0 0 {name=p94 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4610 -820 0 1 {name=x32}
C {devices/lab_pin.sym} -4890 -770 0 0 {name=p95 sig_type=std_logic lab=gpio_noesd[10]}
C {devices/lab_pin.sym} -4860 -930 0 0 {name=p96 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4860 -910 0 0 {name=p97 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4860 -890 0 0 {name=p98 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4860 -870 0 0 {name=p99 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4610 -580 0 1 {name=x33}
C {devices/lab_pin.sym} -4890 -530 0 0 {name=p100 sig_type=std_logic lab=gpio_noesd[11]}
C {devices/lab_pin.sym} -4860 -690 0 0 {name=p101 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4860 -670 0 0 {name=p102 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4860 -650 0 0 {name=p103 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4860 -630 0 0 {name=p104 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4610 -330 0 1 {name=x34}
C {devices/lab_pin.sym} -4890 -280 0 0 {name=p105 sig_type=std_logic lab=gpio_noesd[12]}
C {devices/lab_pin.sym} -4860 -440 0 0 {name=p106 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4860 -420 0 0 {name=p107 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4860 -400 0 0 {name=p108 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4860 -380 0 0 {name=p109 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4610 -100 0 1 {name=x35}
C {devices/lab_pin.sym} -4890 -50 0 0 {name=p110 sig_type=std_logic lab=gpio_noesd[13]}
C {devices/lab_pin.sym} -4860 -210 0 0 {name=p111 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4860 -190 0 0 {name=p112 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4860 -170 0 0 {name=p113 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4860 -150 0 0 {name=p114 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4600 140 0 1 {name=x36}
C {devices/lab_pin.sym} -4880 190 0 0 {name=p115 sig_type=std_logic lab=gpio_noesd[14]}
C {devices/lab_pin.sym} -4850 30 0 0 {name=p116 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4850 50 0 0 {name=p117 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4850 70 0 0 {name=p118 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4850 90 0 0 {name=p119 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4600 360 0 1 {name=x37}
C {devices/lab_pin.sym} -4880 410 0 0 {name=p120 sig_type=std_logic lab=gpio_noesd[15]}
C {devices/lab_pin.sym} -4850 250 0 0 {name=p121 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4850 270 0 0 {name=p122 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4850 290 0 0 {name=p123 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4850 310 0 0 {name=p124 sig_type=std_logic lab=vssa2}
C {switch_array_2.sym} -4600 590 0 1 {name=x38}
C {devices/lab_pin.sym} -4880 640 0 0 {name=p125 sig_type=std_logic lab=gpio_noesd[16]}
C {devices/lab_pin.sym} -4850 480 0 0 {name=p126 sig_type=std_logic lab=vdda2}
C {devices/lab_pin.sym} -4850 500 0 0 {name=p127 sig_type=std_logic lab=vccd2}
C {devices/lab_pin.sym} -4850 520 0 0 {name=p128 sig_type=std_logic lab=vssd2}
C {devices/lab_pin.sym} -4850 540 0 0 {name=p129 sig_type=std_logic lab=vssa2}
C {devices/lab_pin.sym} -4880 880 0 0 {name=p130 sig_type=std_logic lab=gpio_analog[17]}
C {switch_array_2.sym} -1720 -1580 0 0 {name=x40}
C {devices/lab_pin.sym} -1470 -1570 0 1 {name=p135 sig_type=std_logic lab=gpio_noesd[6]}
C {devices/lab_pin.sym} -1470 -1690 0 1 {name=p136 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} -1470 -1670 0 1 {name=p137 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -1470 -1650 0 1 {name=p138 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -1470 -1630 0 1 {name=p139 sig_type=std_logic lab=vssa1}
C {switch_array_2.sym} -1720 -1340 0 0 {name=x41}
C {devices/lab_pin.sym} -1470 -1330 0 1 {name=p140 sig_type=std_logic lab=gpio_noesd[5]}
C {devices/lab_pin.sym} -1470 -1450 0 1 {name=p141 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} -1470 -1430 0 1 {name=p142 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -1470 -1410 0 1 {name=p143 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -1470 -1390 0 1 {name=p144 sig_type=std_logic lab=vssa1}
C {switch_array_2.sym} -1710 -1100 0 0 {name=x42}
C {devices/lab_pin.sym} -1460 -1090 0 1 {name=p145 sig_type=std_logic lab=gpio_noesd[4]}
C {devices/lab_pin.sym} -1460 -1210 0 1 {name=p146 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} -1460 -1190 0 1 {name=p147 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -1460 -1170 0 1 {name=p148 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -1460 -1150 0 1 {name=p149 sig_type=std_logic lab=vssa1}
C {switch_array_2.sym} -1710 -860 0 0 {name=x43}
C {devices/lab_pin.sym} -1460 -850 0 1 {name=p150 sig_type=std_logic lab=gpio_noesd[3]}
C {devices/lab_pin.sym} -1460 -970 0 1 {name=p151 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} -1460 -950 0 1 {name=p152 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -1460 -930 0 1 {name=p153 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -1460 -910 0 1 {name=p154 sig_type=std_logic lab=vssa1}
C {switch_array_2.sym} -1710 -370 0 0 {name=x45}
C {devices/lab_pin.sym} -1460 -480 0 1 {name=p161 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} -1460 -460 0 1 {name=p162 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -1460 -440 0 1 {name=p163 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -1460 -420 0 1 {name=p164 sig_type=std_logic lab=vssa1}
C {switch_array_2.sym} -1710 -140 0 0 {name=x46}
C {devices/lab_pin.sym} -1460 -130 0 1 {name=p165 sig_type=std_logic lab=gpio_noesd[0]}
C {devices/lab_pin.sym} -1460 -250 0 1 {name=p166 sig_type=std_logic lab=vdda1}
C {devices/lab_pin.sym} -1460 -230 0 1 {name=p167 sig_type=std_logic lab=vccd1}
C {devices/lab_pin.sym} -1460 -210 0 1 {name=p168 sig_type=std_logic lab=vssd1}
C {devices/lab_pin.sym} -1460 -190 0 1 {name=p169 sig_type=std_logic lab=vssa1}
C {devices/lab_pin.sym} -1460 -360 0 1 {name=p160 sig_type=std_logic lab=gpio_noesd[1]}
C {sky130_ef_ip__ccomp3v_cl.sym} -3700 -580 0 0 {name=x39}
C {devices/lab_pin.sym} -3940 -510 0 0 {name=p131 sig_type=std_logic lab=vssa2}
C {sky130_fd_pr/res_generic_m3.sym} -1650 110 1 0 {name=R14
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -1650 240 1 0 {name=R15
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -1650 360 1 0 {name=R16
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -1650 480 1 0 {name=R17
W=1
L=1
model=res_generic_m3
mult=1}
C {sky130_fd_pr/res_generic_m3.sym} -4720 880 1 0 {name=R18
W=1
L=1
model=res_generic_m3
mult=1}
C {devices/lab_pin.sym} -4590 880 0 1 {name=p132 sig_type=std_logic lab=vbg}
C {devices/lab_pin.sym} -4850 620 0 0 {name=p133 sig_type=std_logic lab=audio_out_p}
C {devices/lab_pin.sym} -3510 580 0 1 {name=p134 sig_type=std_logic lab=audio_out_p}
C {devices/lab_pin.sym} -4850 390 0 0 {name=p155 sig_type=std_logic lab=audio_out_n}
C {devices/lab_pin.sym} -3510 600 0 1 {name=p156 sig_type=std_logic lab=audio_out_n}
C {devices/lab_pin.sym} -4850 350 0 0 {name=p157 sig_type=std_logic lab=pll_vctrl_in}
C {devices/lab_pin.sym} -2890 -340 0 0 {name=p158 sig_type=std_logic lab=pll_vctrl_in}
C {devices/lab_pin.sym} -4850 130 0 0 {name=p159 sig_type=std_logic lab=pll_ibias}
C {devices/lab_pin.sym} -2890 -440 0 0 {name=p170 sig_type=std_logic lab=pll_ibias}
C {devices/lab_pin.sym} -4860 -70 0 0 {name=p171 sig_type=std_logic lab=cdac_out}
C {devices/lab_pin.sym} -3470 -120 0 1 {name=p172 sig_type=std_logic lab=cdac_out}
C {devices/lab_pin.sym} -4860 -110 0 0 {name=p173 sig_type=std_logic lab=pll_fin}
C {devices/lab_pin.sym} -2890 -500 0 0 {name=p174 sig_type=std_logic lab=pll_fin}
C {devices/lab_pin.sym} -4860 -300 0 0 {name=p175 sig_type=std_logic lab=cdac_vl}
C {devices/lab_pin.sym} -3470 -200 0 1 {name=p176 sig_type=std_logic lab=cdac_vl}
C {devices/lab_pin.sym} -4860 -340 0 0 {name=p177 sig_type=std_logic lab=ccomp_vinm}
C {devices/lab_pin.sym} -3940 -530 0 0 {name=p178 sig_type=std_logic lab=ccomp_vinm}
C {devices/lab_pin.sym} -4860 -550 0 0 {name=p179 sig_type=std_logic lab=cdac_vh}
C {devices/lab_pin.sym} -3470 -220 0 1 {name=p180 sig_type=std_logic lab=cdac_vh}
C {devices/lab_pin.sym} -4860 -590 0 0 {name=p181 sig_type=std_logic lab=ccomp_vinp}
C {devices/lab_pin.sym} -3940 -550 0 0 {name=p182 sig_type=std_logic lab=ccomp_vinp}
C {devices/lab_pin.sym} -4860 -790 0 0 {name=p183 sig_type=std_logic lab=vref_vbgtg}
C {devices/lab_pin.sym} -3510 -880 0 1 {name=p184 sig_type=std_logic lab=vref_vbgtg}
C {devices/lab_pin.sym} -4860 -830 0 0 {name=p185 sig_type=std_logic lab=idac_ref_in}
C {devices/lab_pin.sym} -3890 -1820 0 0 {name=p186 sig_type=std_logic lab=idac_ref_in}
C {devices/lab_pin.sym} -4860 -1030 0 0 {name=p187 sig_type=std_logic lab=vref_vbgsc}
C {devices/lab_pin.sym} -3510 -910 0 1 {name=p188 sig_type=std_logic lab=vref_vbgsc}
C {devices/lab_pin.sym} -4860 -1070 0 0 {name=p189 sig_type=std_logic lab=ldo_vout}
C {devices/lab_pin.sym} -3440 -1310 0 1 {name=p190 sig_type=std_logic lab=ldo_vout}
C {devices/lab_pin.sym} -4870 -1270 0 0 {name=p191 sig_type=std_logic lab=vref_vbg}
C {devices/lab_pin.sym} -3510 -940 0 1 {name=p192 sig_type=std_logic lab=vref_vbg}
C {devices/lab_pin.sym} -4870 -1310 0 0 {name=p193 sig_type=std_logic lab=idac_snk_out}
C {devices/lab_pin.sym} -3470 -1720 0 1 {name=p194 sig_type=std_logic lab=idac_snk_out}
C {devices/lab_pin.sym} -4870 -1510 0 0 {name=p195 sig_type=std_logic lab=vref_vptat}
C {devices/lab_pin.sym} -4870 -1550 0 0 {name=p196 sig_type=std_logic lab=idac_src_out}
C {devices/lab_pin.sym} -3470 -1740 0 1 {name=p197 sig_type=std_logic lab=idac_src_out}
C {devices/lab_pin.sym} -3510 -850 0 1 {name=p198 sig_type=std_logic lab=vref_vptat}
C {devices/lab_pin.sym} -1460 -110 0 1 {name=p199 sig_type=std_logic lab=rdac_out}
C {devices/lab_pin.sym} -2460 970 0 1 {name=p200 sig_type=std_logic lab=rdac_out}
C {devices/lab_pin.sym} -1460 -150 0 1 {name=p201 sig_type=std_logic lab=rheostat_out}
C {devices/lab_pin.sym} -2470 510 0 1 {name=p202 sig_type=std_logic lab=rheostat_out}
C {devices/lab_pin.sym} -1460 -340 0 1 {name=p203 sig_type=std_logic lab=rheostat_vl}
C {devices/lab_pin.sym} -2470 640 0 1 {name=p204 sig_type=std_logic lab=rheostat_vl}
C {devices/lab_pin.sym} -1750 240 0 0 {name=p205 sig_type=std_logic lab=rheostat_vl}
C {devices/lab_pin.sym} -1460 -380 0 1 {name=p206 sig_type=std_logic lab=rdac_vl}
C {devices/lab_pin.sym} -2460 1100 0 1 {name=p207 sig_type=std_logic lab=rdac_vl}
C {devices/lab_pin.sym} -1750 480 0 0 {name=p208 sig_type=std_logic lab=rdac_vl}
C {devices/lab_pin.sym} -2470 380 0 1 {name=p209 sig_type=std_logic lab=rheostat_vh}
C {devices/lab_pin.sym} -1750 110 0 0 {name=p210 sig_type=std_logic lab=rheostat_vh}
C {devices/lab_pin.sym} -1460 -830 0 1 {name=p211 sig_type=std_logic lab=rheostat_vh}
C {devices/lab_pin.sym} -1460 -870 0 1 {name=p212 sig_type=std_logic lab=rdac_vh}
C {devices/lab_pin.sym} -2460 840 0 1 {name=p213 sig_type=std_logic lab=rdac_vh}
C {devices/lab_pin.sym} -1750 360 0 0 {name=p215 sig_type=std_logic lab=rdac_vh}
C {devices/lab_pin.sym} -1460 -1070 0 1 {name=p216 sig_type=std_logic lab=pll_lf}
C {devices/lab_pin.sym} -2890 -180 0 0 {name=p217 sig_type=std_logic lab=pll_lf}
C {devices/lab_pin.sym} -1460 -1110 0 1 {name=p218 sig_type=std_logic lab=ulpcomp_vinp}
C {devices/lab_pin.sym} -2840 -1090 0 0 {name=p219 sig_type=std_logic lab=ulpcomp_vinp}
C {devices/lab_pin.sym} -2450 -1050 0 1 {name=p221 sig_type=std_logic lab=io_out[10]}
C {devices/lab_pin.sym} -1470 -1350 0 1 {name=p222 sig_type=std_logic lab=sample_in}
C {devices/lab_pin.sym} -2850 -1430 0 0 {name=p223 sig_type=std_logic lab=sample_in}
C {devices/lab_pin.sym} -1470 -1550 0 1 {name=p224 sig_type=std_logic lab=ulpcomp_vinn}
C {devices/lab_pin.sym} -2840 -1060 0 0 {name=p225 sig_type=std_logic lab=ulpcomp_vinn}
C {devices/lab_pin.sym} -1470 -1590 0 1 {name=p226 sig_type=std_logic lab=sample_out}
C {devices/lab_pin.sym} -2410 -1490 0 1 {name=p227 sig_type=std_logic lab=sample_out}
C {devices/lab_pin.sym} -2460 -1800 0 1 {name=p229 sig_type=std_logic lab=io_out[13]}
C {devices/lab_pin.sym} -2430 -620 0 1 {name=p230 sig_type=std_logic lab=io_out[11]}
C {devices/lab_pin.sym} -3460 -630 0 1 {name=p220 sig_type=std_logic lab=io_out[17]}
C {devices/lab_pin.sym} -3570 170 0 1 {name=p231 sig_type=std_logic lab=io_out[21]}
C {devices/lab_pin.sym} -3970 640 0 0 {name=p232 sig_type=std_logic lab=io_in[25]}
C {devices/lab_pin.sym} -3970 620 0 0 {name=p233 sig_type=std_logic lab=io_in[26]}
C {devices/lab_pin.sym} -2500 200 0 1 {name=p234 sig_type=std_logic lab=io_out[7]}
C {devices/lab_pin.sym} -2500 220 0 1 {name=p235 sig_type=std_logic lab=io_out[8]}
C {devices/lab_pin.sym} -2500 240 0 1 {name=p236 sig_type=std_logic lab=por_outh[1:0]}
C {devices/lab_pin.sym} -1470 -1310 0 1 {name=p237 sig_type=std_logic lab=por_outh[1]}
C {devices/lab_pin.sym} -2430 -580 0 1 {name=p238 sig_type=std_logic lab=io_out[15]}
C {devices/lab_pin.sym} -2430 -560 0 1 {name=p239 sig_type=std_logic lab=io_out[16]}
C {devices/lab_pin.sym} -2430 -540 0 1 {name=p240 sig_type=std_logic lab=io_out[14]}
C {devices/lab_pin.sym} -2890 -600 0 0 {name=p241 sig_type=std_logic lab=la_oenb[102]}
C {devices/lab_pin.sym} -2890 -660 0 0 {name=p242 sig_type=std_logic lab=la_oenb[103]}
C {devices/lab_pin.sym} -2430 -640 0 1 {name=p243 sig_type=std_logic lab=io_out[20]}
C {devices/lab_pin.sym} -2430 -500 0 1 {name=p244 sig_type=std_logic lab=io_out[18]}
C {devices/lab_pin.sym} -2430 -520 0 1 {name=p245 sig_type=std_logic lab=io_out[19]}
C {devices/lab_pin.sym} -2430 -600 0 1 {name=p246 sig_type=std_logic lab=io_out[12]}
C {devices/lab_pin.sym} -3950 170 0 0 {name=p247 sig_type=std_logic lab=la_data_in[20]}
C {devices/lab_pin.sym} -3950 -40 0 0 {name=p248 sig_type=std_logic lab=la_oenb[26]}
C {devices/lab_pin.sym} -3950 -300 0 0 {name=p249 sig_type=std_logic lab=la_data_in[26]}
C {devices/lab_pin.sym} -3950 -280 0 0 {name=p250 sig_type=std_logic lab=la_oenb[25]}
C {devices/lab_pin.sym} -3950 -260 0 0 {name=p251 sig_type=std_logic lab=la_data_in[25]}
C {devices/lab_pin.sym} -3950 -240 0 0 {name=p252 sig_type=std_logic lab=la_oenb[24]}
C {devices/lab_pin.sym} -3950 -200 0 0 {name=p253 sig_type=std_logic lab=la_oenb[23]}
C {devices/lab_pin.sym} -3950 -160 0 0 {name=p254 sig_type=std_logic lab=la_oenb[22]}
C {devices/lab_pin.sym} -3950 -120 0 0 {name=p255 sig_type=std_logic lab=la_oenb[21]}
C {devices/lab_pin.sym} -3950 -80 0 0 {name=p256 sig_type=std_logic lab=la_oenb[20]}
C {devices/lab_pin.sym} -3950 -220 0 0 {name=p257 sig_type=std_logic lab=la_data_in[24]}
C {devices/lab_pin.sym} -3950 -180 0 0 {name=p258 sig_type=std_logic lab=la_data_in[23]}
C {devices/lab_pin.sym} -3950 -140 0 0 {name=p259 sig_type=std_logic lab=la_data_in[22]}
C {devices/lab_pin.sym} -3950 -100 0 0 {name=p260 sig_type=std_logic lab=la_data_in[21]}
C {devices/lab_pin.sym} -3940 -490 0 0 {name=p261 sig_type=std_logic lab=la_data_in[27]}
C {devices/lab_pin.sym} -3900 -970 0 0 {name=p262 sig_type=std_logic lab=la_oenb[27]}
C {devices/lab_pin.sym} -3900 -850 0 0 {name=p263 sig_type=std_logic lab=la_data_in[28]}
C {devices/lab_pin.sym} -3900 -880 0 0 {name=p264 sig_type=std_logic lab=la_oenb[28]}
C {devices/lab_pin.sym} -3900 -910 0 0 {name=p265 sig_type=std_logic lab=la_data_in[29]}
C {devices/lab_pin.sym} -3900 -940 0 0 {name=p266 sig_type=std_logic lab=la_oenb[29]}
C {devices/lab_pin.sym} -3900 -1270 0 0 {name=p267 sig_type=std_logic lab=la_oenb[30]}
C {devices/lab_pin.sym} -3900 -1230 0 0 {name=p269 sig_type=std_logic lab=la_data_in[30]}
C {devices/lab_pin.sym} -3890 -1840 0 0 {name=p270 sig_type=std_logic lab=la_oenb[35]}
C {devices/lab_pin.sym} -3890 -1780 0 0 {name=p271 sig_type=std_logic lab=la_data_in[35]}
C {devices/lab_pin.sym} -3890 -1720 0 0 {name=p273 sig_type=std_logic lab=la_data_in[31],la_oenb[31],la_data_in[32],la_oenb[32],la_data_in[33],la_oenb[33],la_data_in[34],la_oenb[34]}
C {devices/lab_pin.sym} -2790 -1800 0 0 {name=p274 sig_type=std_logic lab=la_oenb[90]}
C {devices/lab_pin.sym} -2850 -1410 0 0 {name=p275 sig_type=std_logic lab=la_data_in[91]}
C {devices/lab_pin.sym} -2850 -1450 0 0 {name=p276 sig_type=std_logic lab=la_oenb[91]}
C {devices/lab_pin.sym} -2840 -1010 0 0 {name=p278 sig_type=std_logic lab=la_data_in[107]}
C {devices/lab_pin.sym} -2840 -990 0 0 {name=p279 sig_type=std_logic lab=la_oenb[106]}
C {devices/lab_pin.sym} -2900 880 0 0 {name=p280 sig_type=std_logic lab=la_oenb[115]}
C {devices/lab_pin.sym} -2900 900 0 0 {name=p281 sig_type=std_logic lab=la_oenb[111]}
C {devices/lab_pin.sym} -2900 920 0 0 {name=p282 sig_type=std_logic lab=la_data_in[112]}
C {devices/lab_pin.sym} -2900 940 0 0 {name=p283 sig_type=std_logic lab=la_oenb[112]}
C {devices/lab_pin.sym} -2900 960 0 0 {name=p284 sig_type=std_logic lab=la_data_in[113]}
C {devices/lab_pin.sym} -2900 980 0 0 {name=p285 sig_type=std_logic lab=la_oenb[113]}
C {devices/lab_pin.sym} -2900 1000 0 0 {name=p286 sig_type=std_logic lab=la_data_in[114]}
C {devices/lab_pin.sym} -2900 1020 0 0 {name=p287 sig_type=std_logic lab=la_oenb[114]}
C {devices/lab_pin.sym} -2900 1040 0 0 {name=p288 sig_type=std_logic lab=la_data_in[115]}
C {devices/lab_pin.sym} -2910 440 0 0 {name=p289 sig_type=std_logic lab=la_oenb[107]}
C {devices/lab_pin.sym} -2910 460 0 0 {name=p290 sig_type=std_logic lab=la_data_in[108]}
C {devices/lab_pin.sym} -2910 480 0 0 {name=p291 sig_type=std_logic lab=la_oenb[108]}
C {devices/lab_pin.sym} -2910 520 0 0 {name=p292 sig_type=std_logic lab=la_oenb[109]}
C {devices/lab_pin.sym} -2910 560 0 0 {name=p293 sig_type=std_logic lab=la_oenb[110]}
C {devices/lab_pin.sym} -2910 500 0 0 {name=p294 sig_type=std_logic lab=la_data_in[109]}
C {devices/lab_pin.sym} -2910 540 0 0 {name=p295 sig_type=std_logic lab=la_data_in[110]}
C {devices/lab_pin.sym} -2910 580 0 0 {name=p296 sig_type=std_logic lab=la_data_in[111]}
C {devices/lab_pin.sym} -2890 -20 0 0 {name=p297 sig_type=std_logic lab=la_data_in[92]}
C {devices/lab_pin.sym} -2890 -40 0 0 {name=p298 sig_type=std_logic lab=la_oenb[92]}
C {devices/lab_pin.sym} -2890 -60 0 0 {name=p299 sig_type=std_logic lab=la_data_in[93]}
C {devices/lab_pin.sym} -2890 -480 0 0 {name=p301 sig_type=std_logic lab=la_oenb[93]}
C {devices/lab_pin.sym} -2890 -540 0 0 {name=p302 sig_type=std_logic lab=la_data_in[94]}
C {devices/lab_pin.sym} -2890 -580 0 0 {name=p303 sig_type=std_logic lab=la_oenb[94]}
C {devices/lab_pin.sym} -2890 -640 0 0 {name=p304 sig_type=std_logic lab=la_data_in[95]}
C {devices/lab_pin.sym} -2890 -700 0 0 {name=p305 sig_type=std_logic lab=la_oenb[95]}
C {devices/lab_pin.sym} -2890 -680 0 0 {name=p306 sig_type=std_logic lab=la_data_in[96]}
C {devices/lab_pin.sym} -2890 -620 0 0 {name=p307 sig_type=std_logic lab=la_oenb[96]}
C {devices/lab_pin.sym} -2890 -560 0 0 {name=p308 sig_type=std_logic lab=la_data_in[97]}
C {devices/lab_pin.sym} -2890 -520 0 0 {name=p309 sig_type=std_logic lab=la_oenb[97]}
C {devices/lab_pin.sym} -2890 -460 0 0 {name=p310 sig_type=std_logic lab=la_data_in[98]}
C {devices/lab_pin.sym} -2890 -420 0 0 {name=p311 sig_type=std_logic lab=la_oenb[98]}
C {devices/lab_pin.sym} -2890 -360 0 0 {name=p312 sig_type=std_logic lab=la_data_in[99]}
C {devices/lab_pin.sym} -2890 -120 0 0 {name=p313 sig_type=std_logic lab=la_data_in[100]}
C {devices/lab_pin.sym} -2890 -140 0 0 {name=p314 sig_type=std_logic lab=la_oenb[100]}
C {devices/lab_pin.sym} -2890 -200 0 0 {name=p315 sig_type=std_logic lab=la_data_in[101]}
C {devices/lab_pin.sym} -2890 -240 0 0 {name=p317 sig_type=std_logic lab=la_oenb[101]}
C {devices/lab_pin.sym} -2890 -280 0 0 {name=p318 sig_type=std_logic lab=la_data_in[102]}
C {devices/lab_pin.sym} -2890 -380 0 0 {name=p319 sig_type=std_logic lab=la_data_in[103]}
C {devices/lab_pin.sym} -2890 -400 0 0 {name=p320 sig_type=std_logic lab=la_data_in[104]}
C {devices/lab_pin.sym} -2890 -320 0 0 {name=p321 sig_type=std_logic lab=la_oenb[104]}
C {devices/lab_pin.sym} -2890 -260 0 0 {name=p322 sig_type=std_logic lab=la_data_in[105]}
C {devices/lab_pin.sym} -2890 -220 0 0 {name=p323 sig_type=std_logic lab=la_oenb[105]}
C {devices/lab_pin.sym} -2890 -160 0 0 {name=p324 sig_type=std_logic lab=la_data_in[106]}
C {devices/lab_pin.sym} 410 -260 0 1 {name=p327 sig_type=std_logic lab=la_data_in[54]}
C {devices/lab_pin.sym} -1550 240 0 1 {name=p328 sig_type=std_logic lab=io_in_3v3[6]}
C {devices/lab_pin.sym} -1550 110 0 1 {name=p329 sig_type=std_logic lab=io_in_3v3[5]}
C {devices/lab_pin.sym} -1550 480 0 1 {name=p330 sig_type=std_logic lab=io_in_3v3[4]}
C {devices/lab_pin.sym} -1550 360 0 1 {name=p331 sig_type=std_logic lab=io_in_3v3[3]}
C {devices/lab_pin.sym} -4410 630 0 1 {name=p332 sig_type=std_logic lab=la_data_in[1],la_oenb[1]}
C {devices/lab_pin.sym} -4410 590 0 1 {name=p333 sig_type=std_logic lab=la_data_in[0],la_oenb[0]}
C {devices/lab_pin.sym} -4410 400 0 1 {name=p334 sig_type=std_logic lab=la_data_in[3],la_oenb[3]}
C {devices/lab_pin.sym} -4410 360 0 1 {name=p335 sig_type=std_logic lab=la_data_in[2],la_oenb[2]}
C {devices/lab_pin.sym} -4410 180 0 1 {name=p336 sig_type=std_logic lab=la_data_in[5],la_oenb[5]}
C {devices/lab_pin.sym} -4410 140 0 1 {name=p337 sig_type=std_logic lab=la_data_in[4],la_oenb[4]}
C {devices/lab_pin.sym} -4420 -60 0 1 {name=p338 sig_type=std_logic lab=la_data_in[7],la_oenb[7]}
C {devices/lab_pin.sym} -4420 -100 0 1 {name=p339 sig_type=std_logic lab=la_data_in[6],la_oenb[6]}
C {devices/lab_pin.sym} -4420 -290 0 1 {name=p340 sig_type=std_logic lab=la_data_in[9],la_oenb[9]}
C {devices/lab_pin.sym} -4420 -330 0 1 {name=p341 sig_type=std_logic lab=la_data_in[8],la_oenb[8]}
C {devices/lab_pin.sym} -4420 -540 0 1 {name=p342 sig_type=std_logic lab=la_data_in[11],la_oenb[11]}
C {devices/lab_pin.sym} -4420 -580 0 1 {name=p343 sig_type=std_logic lab=la_data_in[10],la_oenb[10]}
C {devices/lab_pin.sym} -4420 -780 0 1 {name=p344 sig_type=std_logic lab=la_data_in[13],la_oenb[13]}
C {devices/lab_pin.sym} -4420 -820 0 1 {name=p345 sig_type=std_logic lab=la_data_in[12],la_oenb[12]}
C {devices/lab_pin.sym} -4420 -1020 0 1 {name=p346 sig_type=std_logic lab=la_data_in[15],la_oenb[15]}
C {devices/lab_pin.sym} -4420 -1060 0 1 {name=p347 sig_type=std_logic lab=la_data_in[14],la_oenb[14]}
C {devices/lab_pin.sym} -4430 -1260 0 1 {name=p350 sig_type=std_logic lab=la_data_in[17],la_oenb[17]}
C {devices/lab_pin.sym} -4430 -1300 0 1 {name=p351 sig_type=std_logic lab=la_data_in[16],la_oenb[16]}
C {devices/lab_pin.sym} -4430 -1500 0 1 {name=p352 sig_type=std_logic lab=la_data_in[19],la_oenb[19]}
C {devices/lab_pin.sym} -4430 -1540 0 1 {name=p353 sig_type=std_logic lab=la_data_in[18],la_oenb[18]}
C {devices/lab_pin.sym} -1900 -100 0 0 {name=p354 sig_type=std_logic lab=la_oenb[126],la_data_in[126]}
C {devices/lab_pin.sym} -1900 -140 0 0 {name=p355 sig_type=std_logic lab=la_oenb[127],la_data_in[127]}
C {devices/lab_pin.sym} -1900 -330 0 0 {name=p356 sig_type=std_logic lab=la_oenb[124],la_data_in[124]}
C {devices/lab_pin.sym} -1900 -370 0 0 {name=p357 sig_type=std_logic lab=la_oenb[125],la_data_in[125]}
C {devices/lab_pin.sym} -1900 -820 0 0 {name=p358 sig_type=std_logic lab=la_oenb[122],la_data_in[122]}
C {devices/lab_pin.sym} -1900 -860 0 0 {name=p359 sig_type=std_logic lab=la_oenb[123],la_data_in[123]}
C {devices/lab_pin.sym} -1900 -1060 0 0 {name=p360 sig_type=std_logic lab=la_oenb[120],la_data_in[120]}
C {devices/lab_pin.sym} -1900 -1100 0 0 {name=p361 sig_type=std_logic lab=la_oenb[121],la_data_in[121]}
C {devices/lab_pin.sym} -1910 -1300 0 0 {name=p362 sig_type=std_logic lab=la_oenb[118],la_data_in[118]}
C {devices/lab_pin.sym} -1910 -1340 0 0 {name=p363 sig_type=std_logic lab=la_oenb[119],la_data_in[119]}
C {devices/lab_pin.sym} -1910 -1540 0 0 {name=p364 sig_type=std_logic lab=la_oenb[116],la_data_in[116]}
C {devices/lab_pin.sym} -1910 -1580 0 0 {name=p365 sig_type=std_logic lab=la_oenb[117],la_data_in[117]}
C {sky130_aa_ip__programmable_pll.sym} -2650 -290 0 0 {name=x17}
C {devices/lab_pin.sym} 510 390 0 1 {name=p366 sig_type=std_logic lab=io_oeb[21]
]}
C {sky130_fd_pr/res_generic_m3.sym} 450 390 1 0 {name=R19
W=1
L=1
model=res_generic_m3
mult=1}
C {devices/ipin.sym} -3670 1050 0 0 {name=p367 lab=la_oenb[127:0]}
C {devices/ipin.sym} -3670 840 0 0 {name=p368 lab=io_in[26:0]}
C {devices/ipin.sym} -3670 810 0 0 {name=p369 lab=io_in_3v3[26:0]}
